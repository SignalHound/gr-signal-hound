options:
  parameters:
    author: Signal Hound
    category: Custom
    generate_options: qt_gui
    id: am_receiver
    output_language: python
    title: AM Receiver
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: 9.375e3
    step: 9.375e3
    stop: 23.592960e6
    value: 180e3
  states: {}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: 'UHD Freq '
    start: 540e3
    step: 10e3
    stop: 1700e3
    value: 1080e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 4
    label: Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '.5'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: 10e3
    audio_stop: 11e3
    chan_rate: 480e3
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 106.7e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '120'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    label: Power
    name: '"Demod Out"'
    type: float
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tun_freq
    fftsize: '1024'
    label: Power
    name: '"Sampling Bandpass"'
    type: complex
    wintype: window.WIN_KAISER
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '625'
    interp: '384'
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 781.25e3
  states: {}
- name: signal_hound_sm_series_0
  id: signal_hound_sm_series
  parameters:
    atten: '-1'
    bandwidth: bandwidth
    center: tun_freq
    decimation: '64'
    purge: 'True'
    reflevel: '-20'
    swfilter: 'True'
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx, '0']
- [analog_am_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']
- [rational_resampler_xxx_0, '0', analog_am_demod_cf_0, '0']
- [signal_hound_sm_series_0, '0', qtgui_freq_sink_x_1, '0']
- [signal_hound_sm_series_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
