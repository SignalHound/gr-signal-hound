options:
  parameters:
    author: Signal Hound
    category: Custom
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: 9.375e3
    step: 9.375e3
    stop: 23.592960e6
    value: 180e3
  states: {}
- name: fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: Fine Freq (MHz)
    start: '-.1'
    step: '.01'
    stop: '.1'
    value: freq - int(freq)
  states: {}
- name: lowpass
  id: variable_qtgui_range
  parameters:
    label: Lowpass Cutoff
    start: 100e6
    step: 1e6
    stop: 106.7e6
    value: 106.7e6
  states: {}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: UHD Freq (MHz)
    start: '87.9'
    step: '0.1'
    stop: '108.1'
    value: freq/1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 4
    label: Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '.5'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 106.7e6
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '120'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    label: Power
    name: '"Demod Out"'
    type: float
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    fc: (tun_freq+fine)*1e6
    fftsize: '2048'
    label: Power
    name: '"Sampling Bandpass"'
    type: complex
    wintype: window.WIN_KAISER
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6250'
    interp: '384'
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 480e3
  states: {}
- name: signal_hound_sm_series_0
  id: signal_hound_sm_series
  parameters:
    atten: '-1'
    bandwidth: bandwidth
    center: (tun_freq+fine)*1e6
    decimation: '64'
    purge: 'False'
    reflevel: '-20'
    swfilter: 'True'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx, '0']
- [signal_hound_sm_series_0, '0', low_pass_filter_0, '0']
- [signal_hound_sm_series_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
