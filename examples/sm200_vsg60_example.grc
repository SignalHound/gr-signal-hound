options:
  parameters:
    generate_options: qt_gui
    id: sm200_vsg60_example
    output_language: python
    title: sm200_vsg60_example
  states: {}

blocks:
- name: sm200_atten
  id: variable_qtgui_range
  parameters:
    label: 'SM200: Attenuation'
    rangeType: int
    start: '-1'
    step: '1'
    stop: '6'
    value: '-1'
  states: {}
- name: sm200_bandwidth
  id: variable_qtgui_range
  parameters:
    label: 'SM200: Bandwidth'
    start: '0'
    step: 1e6
    stop: 50e6
    value: 41.5e6
  states: {}
- name: sm200_center
  id: variable_qtgui_range
  parameters:
    label: 'SM200: Center Frequency'
    start: 100e3
    step: 100e3
    stop: 20e9
    value: 1e9
  states: {}
- name: sm200_decimation
  id: variable_qtgui_chooser
  parameters:
    label: 'SM200: Decimation'
    labels: '[]'
    num_opts: '0'
    options: '[ 1, 2,4,8,16,32,64]'
    type: int
    value: '4'
  states: {}
- name: sm200_reflevel
  id: variable_qtgui_range
  parameters:
    label: 'SM200: Reference Level'
    start: '-160'
    step: '10'
    stop: '20'
    value: '-20'
  states: {}
- name: vsg_center
  id: variable_qtgui_range
  parameters:
    label: 'VSG: Center Frequency'
    start: 50e6
    step: 1e6
    stop: 6e9
    value: 1e9
  states: {}
- name: vsg_ioffset
  id: variable_qtgui_range
  parameters:
    label: 'VSG: I Offset'
    rangeType: int
    start: '-1024'
    step: '1'
    stop: '1024'
    value: '0'
  states: {}
- name: vsg_level
  id: variable_qtgui_range
  parameters:
    label: 'VSG: Level'
    start: '-160'
    step: '1'
    stop: '10'
    value: '-40'
  states: {}
- name: vsg_qoffset
  id: variable_qtgui_range
  parameters:
    label: 'VSG: Q Offset'
    rangeType: int
    start: '-1024'
    step: '1'
    stop: '1024'
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '32000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sm200_bandwidth
    fc: sm200_center
    fftsize: '1024'
    type: complex
    ymax: '20'
    ymin: '-160'
  states: {}
- name: signal_hound_sm_series_0
  id: signal_hound_sm_series
  parameters:
    atten: sm200_atten
    bandwidth: sm200_bandwidth
    center: sm200_center
    decimation: sm200_decimation
    purge: 'False'
    reflevel: sm200_reflevel
    swfilter: 'True'
  states: {}
- name: signal_hound_vsg_series_0
  id: signal_hound_vsg_series
  parameters:
    center: vsg_center
    ioffset: vsg_ioffset
    level: vsg_level
    qoffset: vsg_qoffset
    samplerate: .390625e6
  states: {}

connections:
- [analog_sig_source_x_0, '0', signal_hound_vsg_series_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [signal_hound_sm_series_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
